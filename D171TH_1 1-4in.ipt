# Autodesk Inventor part: D171TH_1 1-4in
## iProperties
Created: 2011-02
Part Number: D171TH_1 1-4in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
